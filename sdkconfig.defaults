## sdkconfig.defaults
```kconfig
# https://docs.espressif.com/projects/esp-idf/en/latest/esp32/api-reference/kconfig.html

CONFIG_ESP_WIFI_ENTERPRISE_SUPPORT=n
CONFIG_BT_ENABLED=n
```
